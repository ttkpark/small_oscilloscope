# Repository ttkpark/small_oscilloscope (continued)

## KiCad design hardware/small_oscilloscope/small_oscilloscope.kicad_pcb (continued)

Parts:
C5, C8: 100u; CP_Elec_5x5.3
C6: 10u; CP_Elec_5x5.3
C7: 47u; CP_Elec_5x5.3
C9: 47u; CP_Elec_6.3x5.7
C10: 10u; CP_Elec_6.3x5.7
D2, D3, D6, D7: 1N5819; D_SOD-123
D4, D5: LED_Small; LED_D3.0mm
J4: BAT; PinSocket_1x02_P2.54mm_Vertical
L1, L2, L3, L4: 10u; L_7.3x7.3_H3.5
L5: 100u; L_7.3x7.3_H3.5
Q13: 2SC4671; SOT-523
R53: 4.7k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R54, R56: 10k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R55: 120; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R57: 147k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R58, R59, R61: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R60: 7.5k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R62: 22k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R63: 2.35k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R64: 3k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R65: 76.9R; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
U6, U7, U9: EA2208T6R; SOT-23-6
U8: TP4056-42-ESOP8; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.3mm_ThermalVias
U10: EA8105; SOT-23-6
U11: LM2576S-12; TO-263-5_TabPin3

Connections:
+3.3V: C9.1, L4.2, R63.1; also elsewhere on the board
+5V: C8.1, D6.1 (K), R62.1, U10.1 (RUN), U10.4 (PWR); also elsewhere on the board
+12V: C7.1, D3.1 (K), R57.1, U11.1 (VIN); also elsewhere on the board
+24V: C6.1, D2.1 (K), R53.1; also elsewhere on the board
-12V: C10.2, D7.2 (A), U11.3 (GND), U11.5 (~ON/OFF); also elsewhere on the board
/BACKLIGHT: R56.1; also elsewhere on the board
/Power/~CHRG: R58.1, U8.7 (~CHRG); also elsewhere on the board
/Power/~STDBY: R59.1, U8.6 (~STDBY); also elsewhere on the board
GND: C5.2, C6.2, C7.2, C8.2, C9.2, C10.1, J4.2, L5.2, Q13.2 (E), R55.2, R60.2, R61.2, R64.2, R65.2, U6.2 (GND), U7.2 (GND), U8.1 (TEMP), U8.3 (GND), U8.9 (EPAD), U9.2 (GND), U10.2 (GND), U11.4 (FB); also elsewhere on the board
unnamed: D2.2 (A), L1.2, U6.1 (SW)
unnamed: D3.2 (A), L2.2, U7.1 (SW)
unnamed: D4.1 (K), R58.2
unnamed: D5.1 (K), R59.2
unnamed: D6.2 (A), L3.2, U9.1 (SW)
unnamed: D7.1 (K), L5.1, U11.2 (OUT)
unnamed: Q13.1 (B), R56.2
unnamed: Q13.3 (C), R54.2, U6.4 (RUN)
unnamed: R53.2, R55.1, U6.3 (FB)
unnamed: R57.2, R60.1, U7.3 (FB)
unnamed: R61.1, U8.2 (PROG)
unnamed: R62.2, R64.1, U9.3 (FB)
unnamed: R63.2, R65.1, U10.6 (FBK)
unnamed: L4.1, U10.3 (SW)
Vbat: C5.1, J4.1, L1.1, L2.1, L3.1, R54.1, U6.5 (PWR), U7.4 (RUN), U7.5 (PWR), U8.5 (BAT), U9.4 (RUN), U9.5 (PWR); also elsewhere on the board
Vusb: D4.2 (A), D5.2 (A), U8.4 (V_{CC}), U8.8 (CE); also elsewhere on the board

Notes on the sheet:
24V Generator Regulation Notes Vo = 0.6(1+R1/R2), R1/R2 = 39.17 = 24.1V LCD Backlight Notes Vf = 21.0V, If = 20mA, Vreg = 24.1V R = (Vr-Vf)/If = 155 if, R=150 If = (Vr-If)/R = 20.7mA, Good.
1K = 1.2A
-12V Generator Inverting Buck-Boost Regulator of LM2576's datasheet
12V Generator Regulation Notes Vo = 0.6(1+R1/R2), R1/R2 = 19 = 12.0V R1 = 147k R2 = 7.5k
# 최종 확정 사항 ## 전원 - 상시 전원 공급 Source : VBAT=2.7 ~ 4.2 - BAT 충전 : 5V -> VBAT=4.2 (TP4056) - 배터리 승압 회로 : VBAT -> 5V (EA2208) - 양전압 생성 회로 : VBAT -> 12V (EA2208) - 음전압 생성 회로 : 12V -> -12V (LM2576) - 백라이트 회로 : VBAT -> 24V (EA2208) - 강하 회로 : 5V -> 3.3V (EA8105)
5V Generator Regulation Notes Vo = 0.6(1+R1/R2), R1/R2 = 7.333 = 5.0V R1 = 22k R2 = 3k
3V3 Generator Regulation Notes Vo = 0.6(1+R1/R2), R1/R2 = 4.5 = 3.3V R1 = 470k R2 = 100k

Parts:
C14: 20p; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
J6: SPEAKER; PinSocket_1x02_P2.54mm_Vertical
R90: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R91, R92: 10k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
U13: LM358; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3.3V: R91.1, U13.8 (V+); also elsewhere on the board
/LCD/Audio/SPEAKER: R90.1; also elsewhere on the board
GND: C14.2, R92.2, U13.4 (V-); also elsewhere on the board
unnamed: J6.1, U13.1, U13.2 (-)
unnamed: J6.2, U13.6 (-), U13.7
unnamed: C14.1, R90.2, U13.3 (+)
unnamed: R91.2, R92.1, U13.5 (+)

Notes on the sheet:
Imax = 16 [mA], Vmax = 3.3 [V] Rmin = 206.25 R = 1k fmax = 48 [kHz], Rmin = 1k, 1/f=RC, Cmin = 1/fRmin = 20.833 [nF] fmax = 8 [kHz], Rmin = 1k, 1/f=RC, Cmin = 1/fRmin = 125 [nF]
4Ohm 3W Speaker Imax = SQRT(P/R) = 0.866 [mA] Vmax = IR = 3.464 if V = 3.3 Imax = V / R = 0.825 [mA], Safe.

Board: 2 copper layers, 177.0 x 99.0 mm, 173 parts (111 on the bottom side), 169 nets.

## Code that names these connections

File main/interactive_test.c (part):

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// CH423_I2C_ADDR는 analog_test_simple.h에서 이미 정의됨

// GPIO 핀 정의
#define GPIO_RE1B 12
#define GPIO_RE1A 13
#define GPIO_RE0B 14
#define GPIO_RE0A 15
#define GPIO_TRIG0 9
#define GPIO_TRIG1 10

// CH423 출력 핀 정의
#define CH423_OC_BACKLIGHT 1
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    uint32_t gpio_num = (uint32_t)arg;
    encoder_interrupt_data_t data;
    
    if (gpio_num == GPIO_RE1A && gpio_get_level(GPIO_RE1A) == 1) {
        data.encoder_id = 1; // RE1
        // RE1A 상승엣지에서 RE1B 상태 확인
        data.direction = gpio_get_level(GPIO_RE1B) == 1; // B=1이면 시계방향
    } else if (gpio_num == GPIO_RE0B && gpio_get_level(GPIO_RE0B) == 0) {
        data.encoder_id = 0; // RE0
        // RE0B 상승엣지에서 RE0A 상태 확인
        data.direction = gpio_get_level(GPIO_RE0A) == 1; // A=0이면 시계방향
    } else {
        return; // 알 수 없는 핀
    }
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    ESP_LOGI(TAG, "Encoder task started (interrupt mode)");
    
    // 초기 상태 읽기 (인터럽트 방식에서는 사용하지 않음)
    re0_last_state = (gpio_get_level(GPIO_RE0A) << 1) | gpio_get_level(GPIO_RE0B);
    re1_last_state = (gpio_get_level(GPIO_RE1A) << 1) | gpio_get_level(GPIO_RE1B);
    
    while (1) {
        // 인터럽트 방식으로 변경되었으므로 폴링 로직 제거
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    
    // 인코더 A 핀들을 상승엣지 인터럽트로 설정
    gpio_config_t io_conf = {
        .pin_bit_mask = (1ULL << GPIO_RE1A),
        .mode = GPIO_MODE_INPUT,
        .pull_up_en = GPIO_PULLUP_ENABLE,
        .pull_down_en = GPIO_PULLDOWN_DISABLE,
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        return ret;
    }
    // 인코더 A 핀들을 상승엣지 인터럽트로 설정
    io_conf.pin_bit_mask = (1ULL << GPIO_RE0B);
    io_conf.intr_type = GPIO_INTR_NEGEDGE; // 상승엣지
    
    ret = gpio_config(&io_conf);
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    }
    
    // RE1A 인터럽트 핸들러 추가
    ret = gpio_isr_handler_add(GPIO_RE1A, encoder_isr_handler, (void*)GPIO_RE1A);
    if (ret != ESP_OK) {
        ESP_LOGE(TAG, "GPIO RE1A ISR handler add failed: %s", esp_err_to_name(ret));
        return ret;
    }
    
    // RE0B 인터럽트 핸들러 추가
    ret = gpio_isr_handler_add(GPIO_RE0B, encoder_isr_handler, (void*)GPIO_RE0B);
    if (ret != ESP_OK) {
        ESP_LOGE(TAG, "GPIO RE0B ISR handler add failed: %s", esp_err_to_name(ret));
        return ret;
    }
    
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// 입력 상태 업데이트
static void update_input_status(void) {
    // 로터리 인코더 상태 읽기
    input_status.re0_a = gpio_get_level(GPIO_RE0A);
    input_status.re0_b = gpio_get_level(GPIO_RE0B);
    input_status.re1_a = gpio_get_level(GPIO_RE1A);
    input_status.re1_b = gpio_get_level(GPIO_RE1B);
    
    // 공용 변수에서 인코더 카운터 가져오기
    input_status.re0_counter = g_re0_counter;
    input_status.re1_counter = g_re1_counter;
    
    // 트리거 상태 읽기
    input_status.trig0_active = !gpio_get_level(GPIO_TRIG0); // Active LOW
    input_status.trig1_active = !gpio_get_level(GPIO_TRIG1); // Active LOW
    
    // CH423 입력 읽기 (배터리 상태만 - 버튼은 폴링 태스크에서 처리)
    uint8_t input_data;
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        y+=inc*2;
        
        // 선택된 LED 표시
        const char* led_names[] = {"LED0", "LED1", "LEDRE0", "LEDRE1"};
        cmd(COLOR_RGB(0xFF, 0xFF, 0x00));
        sprintf(status_text, "Selected: %s", led_names[led_ctrl.selected_led]);
        cmd_text(10, y, 22, 0, status_text);
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
File main/hardware_test.c (part):

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#define CH423_CMD_IO_DIR        0x4A

// GPIO 핀 정의
#define GPIO_RE1B 12
#define GPIO_RE1A 13
#define GPIO_RE0B 14
#define GPIO_RE0A 15
#define GPIO_TRIG0 9
#define GPIO_TRIG1 10
#define GPIO_ADC0 34
#define GPIO_ADC1 4
#define GPIO_DAC_TRIG 25
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static esp_err_t init_gpio(void) {
    // 로터리 인코더 핀 설정 (폴링 방식)
    gpio_config_t io_conf = {
        .pin_bit_mask = (1ULL << GPIO_RE1B) | (1ULL << GPIO_RE1A) | 
                       (1ULL << GPIO_RE0B) | (1ULL << GPIO_RE0A),
        .mode = GPIO_MODE_INPUT,
        .pull_up_en = GPIO_PULLUP_ENABLE,
        .pull_down_en = GPIO_PULLDOWN_DISABLE,
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    if (ret != ESP_OK) return ret;
    
    // 트리거 핀 설정
    io_conf.pin_bit_mask = (1ULL << GPIO_TRIG0) | (1ULL << GPIO_TRIG1);
    ret = gpio_config(&io_conf);
    if (ret != ESP_OK) return ret;

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    int re0_last = 0, re1_last = 0;
    
    // 초기 상태 읽기
    re0_last = (gpio_get_level(GPIO_RE0A) << 1) | gpio_get_level(GPIO_RE0B);
    re1_last = (gpio_get_level(GPIO_RE1A) << 1) | gpio_get_level(GPIO_RE1B);
    
    // 10초간 인코더 변화 감지
    for (int i = 0; i < 100; i++) {
        int re0_current = (gpio_get_level(GPIO_RE0A) << 1) | gpio_get_level(GPIO_RE0B);
        int re1_current = (gpio_get_level(GPIO_RE1A) << 1) | gpio_get_level(GPIO_RE1B);
        
        if (re0_current != re0_last) {
            re0_count++;
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    // }
    
    // 트리거 핀 상태 읽기
    int trig0_level = gpio_get_level(GPIO_TRIG0);
    int trig1_level = gpio_get_level(GPIO_TRIG1);
    
    ESP_LOGI(TAG, "TRIG0 level: %d", trig0_level);
    ESP_LOGI(TAG, "TRIG1 level: %d", trig1_level);
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        return false;
    }
    
    bool stdby = (input_data & (1 << CH423_IO_STDBY)) != 0;
    bool chrg = (input_data & (1 << CH423_IO_CHRG)) != 0;
    
    ESP_LOGI(TAG, "STDBY: %s, CHRG: %s", stdby ? "HIGH" : "LOW", chrg ? "HIGH" : "LOW");
    
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
## Commit log

2025-06-25 infra: ESP-IDF 프로젝트 기본 구조 생성
2025-06-26 250627 circuit
2025-06-27 feat: 오실로스코프 회로 설계 업데이트
2025-06-27 chore: KiCad 프로젝트 백업 파일 정리 및 PCB 파일 업데이트
2025-06-27 feat: 소형 오실로스코프 하드웨어 개발 완료
2025-07-07 board edit
2025-07-13 7534356
2025-07-13 234234
2025-08-20 oscilliscope first success
2025-08-30 feat: oscilliscope dev
2025-09-06 feat: ft800 problem debug add
2025-10-07 fix: program tidy
